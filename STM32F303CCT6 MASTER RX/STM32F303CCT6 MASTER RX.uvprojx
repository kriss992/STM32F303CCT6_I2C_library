# Keil uVision project STM32F303CCT6 MASTER RX.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303CCT6 MASTER RX
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: GPIO.c GPIO.h I2C.c I2C.h main.c RCC.c RCC.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
